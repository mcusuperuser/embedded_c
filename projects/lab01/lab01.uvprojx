# Keil uVision project lab01.uvprojx, settings and files
target Simulation (6130001::V6.13.1::.\ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: lab01
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Sources
    ./: main.c
  group Documentation
    ./: Abstract.md
software components: CMSIS:CORE 5.3.0, Device:Startup 1.2.0, Compiler:I/O:STDOUT 1.2.0
