# Keil uVision project ex02.uvprojx, settings and files
target Empty (6130001::V6.13.1::.\ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0-dev6
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: lab01
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM3\ARMCM3_ac6.sct
  group Sources
    ./: main.c empty_main.c
  group Documentation
    ./: Abstract.md
target Finished (6130001::V6.13.1::.\ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0-dev6
  cpu: as above
  output: lab01
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM3\ARMCM3_ac6.sct
software components: CMSIS:CORE 5.4.0, Device:Startup 2.0.2, Compiler:I/O:STDOUT 1.2.0, Utils:embedded_c 1.0.0
